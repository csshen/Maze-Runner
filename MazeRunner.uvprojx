# Keil uVision project MazeRunner.uvprojx, settings and files
target MazeRunner (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  cpu: CPUTYPE("Cortex-M3")
  output: MazeRunner
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti --split_sections -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M3 -Ospace -DDEVICE_ETHERNET=1 -DTARGET_LPCTarget -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DTARGET_CORTEX -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DMBED_BUILD_TIMESTAMP=1514756462.98 -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; MMA8452; SDFileSystem; SDFileSystem/FATFileSystem; SDFileSystem/FATFileSystem/ChaN; 4DGL-uLCD-SE; wave_player; Servo; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: --show_full_path
  group 4DGL-uLCD-SE
    4DGL-uLCD-SE/: uLCD_4DGL.h uLCD_4DGL_Graphics.cpp uLCD_4DGL_main.cpp uLCD_4DGL_Media.cpp uLCD_4DGL_Text.cpp
  group MazeRunner
    ./: doublely_linked_list.cpp doublely_linked_list.h game.cpp game.h globals.h main.cpp math_extra.cpp math_extra.h mbed_config.h physics.cpp physics.h SongPlayer.h Speaker.h wall.cpp wall.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_LPC1768/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h device.h gpio_object.h LPC17xx.h objects.h PeripheralNames.h PinNames.h PortNames.h system_LPC17xx.h
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed.ar retarget.o startup_LPC17xx.o sys.o system_LPC17xx.o
  group MMA8452
    MMA8452/: MMA8452.cpp MMA8452.h
  group SDFileSystem
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h
    SDFileSystem/: SDFileSystem.cpp SDFileSystem.h
  group Servo
    Servo/: Servo.cpp Servo.h
  group wave_player
    wave_player/: wave_player.cpp wave_player.h
